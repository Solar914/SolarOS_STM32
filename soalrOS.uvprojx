# Keil uVision project soalrOS.uvprojx, settings and files
target SOLAROS (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: SolarOS
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\SolarOS\Inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ./SolarOS/Src/: app.c main.c
  group SolarOS
    ./SolarOS/Src/: tBitmap.c tCpu.c tTime.c tList.c tEvent.c tTask.c tSem.c tMbox.c tMemBlock.c tTimer.c tHooks.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.1
